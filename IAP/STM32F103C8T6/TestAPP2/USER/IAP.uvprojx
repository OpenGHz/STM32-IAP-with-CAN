# Keil uVision project IAP.uvprojx, settings and files
target IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o ..\OBJ\test_app1.bin ..\OBJ\IAP.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\IAP;..\HARDWARE\STMFLASH;..\HARDWARE\CAN;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_can.c
  group README
    ../: README.TXT
